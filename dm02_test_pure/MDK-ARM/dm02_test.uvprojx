# Keil uVision project dm02_test.uvprojx, settings and files
target dm02_test (6160000::V6.16::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: dm02_test +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx,ARM_MATH_CM7,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc;../User_File
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c cordic.c dma.c fdcan.c iwdg.c mdma.c octospi.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cordic.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_ospi.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group Application/User/User_File
    ../User_File/1_Middleware/System/Timestamp/: sys_timestamp.cpp
    ../User_File/1_Middleware/Driver/WDG/: drv_wdg.cpp
  group New Group
    ../User_File/4_Task/: tsk_config_and_callback.cpp tsk_config_and_callback.h
    ../User_File/2_Device/Motor/Motor_DM/: dvc_motor_dm.cpp
    ../User_File/2_Device/Motor/Motor_DJI/: dvc_motor_dji.cpp
    ../User_File/2_Device/BSP/BMI088/: bsp_bmi088.cpp
  group User Sources
    ../User_File/1_Middleware/Algorithm/Basic/: arm_math_compat.cpp alg_basic.cpp
    ../User_File/1_Middleware/Algorithm/Complex/: alg_complex.cpp
    ../User_File/1_Middleware/Algorithm/Filter/EKF/: alg_filter_ekf.cpp
    ../User_File/1_Middleware/Algorithm/Filter/Frequency/: alg_filter_frequency.cpp
    ../User_File/1_Middleware/Algorithm/Filter/Kalman/: alg_filter_kalman.cpp
    ../User_File/1_Middleware/Algorithm/FSM/: alg_fsm.cpp
    ../User_File/1_Middleware/Algorithm/Matrix/: alg_matrix.cpp
    ../User_File/1_Middleware/Algorithm/PID/: alg_pid.cpp
    ../User_File/1_Middleware/Algorithm/Quaternion/: alg_quaternion.cpp
    ../User_File/1_Middleware/Algorithm/Queue/: alg_queue.cpp
    ../User_File/1_Middleware/Algorithm/Slope/: alg_slope.cpp
    ../User_File/1_Middleware/Driver/ADC/: drv_adc.cpp
    ../User_File/1_Middleware/Driver/CAN/: drv_can.cpp
    ../User_File/1_Middleware/Driver/OSPI/: drv_ospi.cpp
    ../User_File/1_Middleware/Driver/SPI/: drv_spi.cpp
    ../User_File/1_Middleware/Driver/UART/: drv_uart.cpp
    ../User_File/1_Middleware/Driver/USB/: drv_usb.cpp
    ../User_File/2_Device/BSP/BMI088/Accel/: bsp_bmi088_accel_register.cpp bsp_bmi088_accel.cpp
    ../User_File/2_Device/BSP/BMI088/Gyro/: bsp_bmi088_gyro_register.cpp bsp_bmi088_gyro.cpp
    ../User_File/2_Device/BSP/Buzzer/: bsp_buzzer.cpp
    ../User_File/2_Device/BSP/Key/: bsp_key.cpp
    ../User_File/2_Device/BSP/Power/: bsp_power.cpp
    ../User_File/2_Device/BSP/W25Q64JV/: bsp_w25q64jv_register.cpp bsp_w25q64jv.cpp
    ../User_File/2_Device/BSP/WS2812/: bsp_ws2812.cpp
    ../User_File/2_Device/Plotter/Serialplot/: dvc_serialplot.cpp
    ../User_File/2_Device/Plotter/Vofa/: dvc_vofa.cpp
    ../User_File/2_Device/Powermeter/: dvc_powermeter.cpp
software components: CMSIS:CORE 4.3.0
